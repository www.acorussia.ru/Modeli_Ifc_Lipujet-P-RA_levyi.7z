Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView, QuantityTakeOffAddOnView]
Time: 2017-05-23T15:04:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 23 15:04:18 2017 * Host: IN-BLR-PC-0012 * Database: C:\Users\palleri\AppData\Local\Temp\{3C0BDD15-5778-4506-BA5E-C68CEFD96AF8}\ifc * Database version: 5507 * Database creation date: Tue May 23 15:04:17 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 23 15:04:17 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 23 15:04:17 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Identity Data - Type Name: Level 1; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcDistributionControlElement: std, ZZZ_do not use_ME_ST_measuring device for grease_ACO:std:18042
In: Level 1
Type - Description: Measuring device for grease layers; PredefinedType: CO2SENSOR; Material: PVC, Grey, HDPE, Black, PVC, White, Stainless Steel, Brushed
Type - Constraints - Default Elevation: 1219.2 mm
Type - Electrical - Loads - RSen_E_c01_load_classification: Power; RSen_E_powerfactor: 1
Type - Electrical Engineering - RSen_E_c01_3_phase: no; RSen_E_c01_current: 0.05 A; RSen_E_c01_number_of_poles: 1; RSen_E_c01_subclass_motor: no; RSen_E_c01_voltage: 230 V
Type - General - instructions_for_use: http://katalog.aco-haustechnik.de/ilcatalogue/download/ZG9jdW1lbnQvZG93bmxvYWQucGRmL2RlL2ViYV8xMC4wMi4xMF9kZV8zMzAwLjExLjUwX2tsX180NDk1NS5wZGY=/eba_10.02.10_de_3300.11.50_kl__44955.pdf; RSen_C_code_ETIM: -; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0
Type - Identity Data - Description: Measuring device for grease layers; LOD: LOD 400; Manufacturer: ACO; Model: ACO measuring device for grease layers; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: For electronic measurement of layer of grease; Type Name: std
Type - Materials and Finishes - RSen_C_material: HDPE, Black
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_ST_measuring device for grease_ACO
Type - Structural - RSen_S_net_mass: 2.8
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Constraints - Offset: 1890 mm
Dimensions - Area: 0.088916 m2; Volume: 0.00155701 m3
Electrical - Loads - RSen_E_c01_apparent_power_phase_1: 12 W; RSen_E_c01_apparent_power_phase_2: 0 W; RSen_E_c01_apparent_power_phase_3: 0 W
Electrical Engineering - RSen_E_connected_fase: 1; RSen_E_c01_apparent_power: 12 W
General - RSen_C_intended_use: Entwässerungssysteme
Identity Data - Mark: 15; RSen_C_code_article: 3300.11.50; RSen_C_code_gtin: 04002626361080; RSen_C_description: ACO Fettschichtdickenmessung für Freiaufst. 3 m Kabel
Mechanical - System Classification: Power
Other - option: 1; Family: ZZZ_do not use_ME_ST_measuring device for grease_ACO: std; Family and Type: ZZZ_do not use_ME_ST_measuring device for grease_ACO: std; help_connected_phase: 1; Type: ZZZ_do not use_ME_ST_measuring device for grease_ACO: std; Type Id: ZZZ_do not use_ME_ST_measuring device for grease_ACO: std
Phasing - Phase Created: New Construction

# IfcFlowController: std, ZZZ_do not use_ME_ST_filling device for Ecojet_ACO:std:18041
In: Level 1
Type - Description: Filling device; PredefinedType: FAUCET; Material: Stainless Steel, Brushed
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - RSen_C_code_ETIM: EC010071; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_P_c01_diameter: 20 mm
Type - Identity Data - Description: Filling device; LOD: LOD 400; Manufacturer: ACO; Model: ACO filling device for Ecojet; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Free outlet as per DIN 1988 Part 4; Type Name: std
Type - Materials and Finishes - RSen_C_material: Stainless Steel, Brushed
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO
Type - Plumbing - p_c01_flow: 0.105944 m3/s
Type - Structural - RSen_S_net_mass: 3.5
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std
Constraints - Moves With Nearby Elements: no; Offset: 2033 mm
Dimensions - Area: 0.0761672 m2; Volume: 0.00141803 m3
Identity Data - Mark: 14; RSen_C_code_article: 3300.11.22; RSen_C_code_gtin: 04002626299253; RSen_C_description: ACO Fülleinheit für Eco-Jet-O,-OD,-R,-RD
Other - option: 0; Family: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO: std; Family and Type: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO: std; Type: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO: std; Type Id: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO: std
Phasing - Phase Created: New Construction

# IfcFlowTerminal: NS10, ME_PE_hydro jet ra extension stage 3_ACO:NS10:18033
In: Level 1
Type - Description: Grease separator plant as per DIN EN 1825 and DIN 4040-100; PredefinedType: GREASEINTERCEPTOR; Material: PVC, White, Steel, Blue, Stainless Steel, Brushed, HDPE, Black
Type - Electrical - Loads - RSen_E_c01_load_classification: Power; RSen_E_powerfactor: 1
Type - Electrical Engineering - RSen_E_c01_3_phase: yes; RSen_E_c01_current: 16 A; RSen_E_c01_number_of_poles: 3; RSen_E_c01_subclass_motor: yes; RSen_E_c01_voltage: 400 V
Type - General - installation_manual: http://katalog.aco-haustechnik.de/ilcatalogue/download/ZG9jdW1lbnQvZG93bmxvYWQucGRmL2RlL0lNMDAwOTczNl9fMjA1ODg0LnBkZg==/IM0009736__205884.pdf; instructions_for_use: http://katalog.aco-haustechnik.de/ilcatalogue/download/ZG9jdW1lbnQvZG93bmxvYWQucGRmL2RlL0VCQV9GQV9GcmVpYXVmc3RlbGx1bmdfcnVuZF91bmRfb3ZhbF9fNDUwMDUucGRm/EBA_FA_Freiaufstellung_rund_und_oval__45005.pdf; RSen_C_code_ETIM: EC010271; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_C_info_technical: http://katalog.aco-haustechnik.de/Home/Produkte/Clean/Fettabscheider/Freiaufstellung/Vollentsorgung/Runde-Bauform-Polyethylen-PE-HD/Hydrojet-RA-Ausbaustufe-3; RSen_C_intended_use: Entwässerungssysteme
Type - Identity Data - Description: Grease separator plant as per DIN EN 1825 and DIN 4040-100; LOD: LOD 400; Manufacturer: ACO; Model: NS 10; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Building Supervisory Authority approval Z-54.1-414; Type Name: NS10
Type - Materials and Finishes - RSen_C_material: HDPE, Black
Type - Other - Category: Mechanical Equipment; Family Name: ME_PE_hydro jet ra extension stage 3_ACO
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: NS10
Constraints - clearance_zone: no; DN_sanitary: yes; filling_device: yes; grease_measure_device: yes; heating_rod: no; inlet_angle: 0 deg; left: no; logo: yes; OD_sanitary: no; Offset: 0 mm; right: yes; sight_glass: yes
Dimensions - Area: 22.3702 m2; D: 160 mm; D1: 1660 mm; D2: 1560 mm; D3: 1525 mm; D4: 1560 mm; disposalpump_angle: 30 deg; disposalpump_OD: 110 mm; disposalpump_X: 981.5 mm; disposalpump_Z: 135 mm; DN: 150 mm; H: 1890 mm; H1: 1600 mm; H2: 1500 mm; H3: 2050 mm; H4: 2250 mm; inlet_length: 930 mm; L1: 1820 mm; L2: 60 mm; L3: 200 mm; outlet_length: 980 mm; Volume: 0.0215364 m3
Electrical - Loads - RSen_E_c01_apparent_power_phase_1: 1300 W; RSen_E_c01_apparent_power_phase_2: 1300 W; RSen_E_c01_apparent_power_phase_3: 1300 W
Electrical Engineering - RSen_E_c01_apparent_power: 3900 W; RSen_E_connected_fase: 1
General - RSen_P_c01_diameter: 150 mm; RSen_P_c02_diameter: 150 mm; RSen_P_c03_diameter: 100 mm; RSen_P_c04_diameter: 20 mm; RSen_P_c05_diameter: 65 mm
Identity Data - Mark: 11; RSen_C_code_article: 3510.73.42; RSen_C_code_gtin: 04002626130884; RSen_C_description: ACO Fettabscheid. Hydrojet RA NS10 Dirabsg.+HD-Rg.rd.rechts
Mechanical - RSen_P_c04_flow: 0 m3/s; System Classification: Sanitary,Vent,Domestic Cold Water,Other,Power
Model Properties - clearance_back: 880 mm; clearance_entry: 1910 mm; clearance_exit: 1010 mm; clearance_front: 1430 mm; clearance_top: 2850 mm; D_drain: 76 mm; DN_drain: 65 mm; drain_X: 324.4 mm; drain_Y: 437.2 mm; drain_Z: 1947 mm; motor_position: 130 deg; motor_Y: 839.2 mm; motor_Z: 694 mm; switchbox_position: 135 deg; switchbox_Y: 881.5 mm; switchbox_Z: 1645 mm
Other - cold_water_connector: cw in; connector_escape_message: Nicht verwenden; extension_stage_lookup_table_name: eco-jet_ra_extension_stage_3; Family: ME_PE_hydro jet ra extension stage 3_ACO: NS10; Family and Type: ME_PE_hydro jet ra extension stage 3_ACO: NS10; help_connected_phase: 3; L2_half: 30 mm; lookup_table_name: ecojet_r_basic; no_option: 0; option: 1; options_lookup_table_name: ecojet_r_options; R: 80 mm; R4: 780 mm; Type: ME_PE_hydro jet ra extension stage 3_ACO: NS10; Type Id: ME_PE_hydro jet ra extension stage 3_ACO: NS10; vent_DN: 100 mm; vent_OD: 110 mm
Phasing - Phase Created: New Construction
Plumbing - grease_store_capacity: 0.4 m3; overall_capacity: 2.45 m3; sludge_trap_capacity: 1.15 m3
Structural - RSen_S_gross_mass: 2814; RSen_S_net_mass: 364

# IfcFlowTerminal: std, ZZZ_do not use_ME_PE_ecojet_r_options_ACO:std:18034
In: Level 1
Type - PredefinedType: GREASEINTERCEPTOR; Material: Plastic, White, HDPE, Red, HDPE, Black
Type - Identity Data - Manufacturer: ACO; Type Name: std
Type - Materials and Finishes - RSen_C_material: HDPE, Black
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_PE_ecojet_r_options_ACO
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std
Constraints - filling_device: yes; grease_measure_device: yes; heating_rod: no; inlet_angle: 0 deg; left: no; logo: yes; Offset: 0 mm; right: yes; sight_glass: yes; Moves With Nearby Elements: no
Dimensions - disposalpump_angle: 30 deg; acces_exit_X: 525 mm; access_entry_bottom_radius: 230 mm; access_entry_radius: 192.5 mm; access_entry_X_position: 525 mm; Area: 19.0359 m2; cover_Z: 1970 mm; D: 160 mm; D1: 1660 mm; D2: 1560 mm; D3: 1525 mm; D4: 1560 mm; disposalpump_flange_OD: 220 mm; disposalpump_flange length: 22 mm; disposalpump_OD: 110 mm; disposalpump_X: 981.5 mm; disposalpump_Z: 135 mm; DN: 150 mm; H: 1890 mm; H1: 1600 mm; H2: 1500 mm; H3: 2050 mm; H4: 2250 mm; inlet_length: 930 mm; L1: 1820 mm; L2: 60 mm; L3: 200 mm; logo_Z: 947 mm; outlet_length: 980 mm; rib_number: 2; rib_thickness: 25 mm; rib_total_thickness: 57.5 mm; rib1_Z: 628.75 mm; rib2_Z: 1226.25 mm; vent_X: 160 mm; vent_Y: 500 mm; Volume: 3.88315 m3; waterinlet_angle: -20 deg; waterinlet_OD: 90 mm; waterinlet_X: 904.5 mm; waterinlet_Z: 1802 mm
General - RSen_P_c01_diameter: 150 mm; RSen_P_c02_diameter: 150 mm
Identity Data - Mark: 12
Model Properties - glass_position: 90 deg; glass_X: 780 mm; glass_Z: 1472 mm; grease_measure_end_angle: 85 deg; grease_measure_start_angle: 90 deg; grease_measure_X: 150 mm; grease_measure_Y: 500 mm; grease_measure_Z: 1890 mm; heatrod_position: 90 deg; heatrod_Z: 1102.5 mm
Other - bottom_part_Z: 603.75 mm; bottom_plate: yes; Family: ZZZ_do not use_ME_PE_ecojet_r_options_ACO: std; Family and Type: ZZZ_do not use_ME_PE_ecojet_r_options_ACO: std; filling_device_option: 0; grease_measure_option: 1; heatrod_option: 1; L2_half: 30 mm; logo_diameter: 1525 mm; logo_position: 90 deg; logo_radius: 762.5 mm; lookup_table_name: ecojet_r_basic; middle_part_Z: 1251.25 mm; options_lookup_table_name: ecojet_r_options; R: 80 mm; R4: 780 mm; sight_glass_option: 0; Type: ZZZ_do not use_ME_PE_ecojet_r_options_ACO: std; type_index: 10; Type Id: ZZZ_do not use_ME_PE_ecojet_r_options_ACO: std; vent_DN: 100 mm; vent_length: 50 mm; vent_OD: 110 mm; waterinlet_end_angle: 15 deg; waterinlet_height: 231 mm; waterinlet_start_angle: 200 deg
Phasing - Phase Created: New Construction

# IfcWindow: std, ZZZ_do not use_ME_PE_viewing window Ecojet_ACO:std:18040
In: Level 1
Type - Description: Viewing window; ParameterTakesPrecedence: no; Sizeable: no; Material: HDPE, Red, HDPE, Black, HDPE, Grey
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - RSen_C_code_ETIM: EC011162; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_C_intended_use: Entwässerungssysteme
Type - Identity Data - Description: Viewing window; LOD: LOD 400; Manufacturer: ACO; Model: ACO viewing window; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Nominal width: DN 200; Type Name: std
Type - Materials and Finishes - RSen_C_material: HDPE, Grey
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO
Type - Structural - RSen_S_net_mass: 5
OverallHeight: 75 mm; OverallWidth: 250 mm
Pset_WindowCommon - Reference: std; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: ACO
BaseQuantities - Area: 0.0878948 m2
Constraints - Moves With Nearby Elements: no; Offset: 1472 mm
Dimensions - Area: 0.0878948 m2; Volume: 0.00175086 m3
Identity Data - Mark: 13; RSen_C_code_article: 3300.11.10; RSen_C_code_gtin: 04002626130280; RSen_C_description: ACO Schauglas LW 200 f. Eco-Jet-O,-OD,-R,-RD
Other - Family: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO: std; Family and Type: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO: std; option: 0; Type: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO: std; Type Id: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO: std
Phasing - Phase Created: New Construction
